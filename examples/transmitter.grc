<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>transmitter</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoding</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fl</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>737.5e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>logical_channels</value></param>
<param><key>value</key><value>[52,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,43,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,42,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,33,34,35,36,37,48,49,50,51,52,53,54,55,56,57,58,42,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,33,34,35,36,37,38,39,40,41,42,43,54,55,56,57,58,43,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mode</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>12500000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sensor_skip</value></param>
<param><key>value</key><value>samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>spf</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vec</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>1472</value></param>
<param><key>port</key><value>8888</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>host</key><value>192.168.11.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52002</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_CLIENT"</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>vec</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>vec</value></param>
</block>
<block>
<key>fbmc1_fbmc_add</key>
<param><key>id</key><value>fbmc1_fbmc_add_0</value></param>
<param><key>veclength</key><value>vec</value></param>
</block>
<block>
<key>fbmc1_fbmc_carrier_allocator</key>
<param><key>id</key><value>fbmc1_fbmc_carrier_allocator_0</value></param>
<param><key>filterlength</key><value>fl</value></param>
<param><key>microseconds</key><value>100</value></param>
<param><key>preamble_set</key><value>preamble</value></param>
<param><key>veclength</key><value>vec</value></param>
</block>
<block>
<key>fbmc1_fbmc_log_chann_state</key>
<param><key>id</key><value>fbmc1_fbmc_log_chann_state_0</value></param>
<param><key>avg</key><value>50</value></param>
<param><key>fft_length</key><value>1</value></param>
<param><key>logical_channels</key><value>logical_channels</value></param>
<param><key>veclength</key><value>vec</value></param>
</block>
<block>
<key>fbmc1_fbmc_mac_encoder</key>
<param><key>id</key><value>fbmc1_fbmc_mac_encoder_0</value></param>
</block>
<block>
<key>fbmc1_fbmc_oqam</key>
<param><key>id</key><value>fbmc1_fbmc_oqam_0</value></param>
<param><key>veclength</key><value>vec</value></param>
</block>
<block>
<key>fbmc1_fbmc_p2s</key>
<param><key>id</key><value>fbmc1_fbmc_p2s_0</value></param>
<param><key>delayed</key><value>0</value></param>
<param><key>veclength</key><value>vec</value></param>
</block>
<block>
<key>fbmc1_fbmc_p2s</key>
<param><key>id</key><value>fbmc1_fbmc_p2s_1</value></param>
<param><key>delayed</key><value>1</value></param>
<param><key>veclength</key><value>vec</value></param>
</block>
<block>
<key>fbmc1_fbmc_payload_generator</key>
<param><key>id</key><value>fbmc1_fbmc_payload_generator_0</value></param>
<param><key>logical_channels</key><value>logical_channels</value></param>
<param><key>mode</key><value>mode</value></param>
<param><key>sensor_chunk_len</key><value>20000</value></param>
<param><key>sensor_skip</key><value>sensor_skip</value></param>
<param><key>symbols_per_frame</key><value>spf</value></param>
<param><key>video_encoding</key><value>encoding</value></param>
</block>
<block>
<key>fbmc1_fbmc_phy_encoder</key>
<param><key>id</key><value>fbmc1_fbmc_phy_encoder_0</value></param>
</block>
<block>
<key>fbmc1_fbmc_ppn</key>
<param><key>id</key><value>fbmc1_fbmc_ppn_0</value></param>
<param><key>filterlength</key><value>fl</value></param>
<param><key>normalize</key><value>0.05</value></param>
<param><key>veclength</key><value>vec</value></param>
</block>
<block>
<key>fbmc1_fbmc_sample_collector</key>
<param><key>id</key><value>fbmc1_fbmc_sample_collector_0</value></param>
<param><key>mode</key><value>mode</value></param>
<param><key>sensor_chunk_len</key><value>samp_rate/2</value></param>
<param><key>sensor_pre_push</key><value>2</value></param>
<param><key>sensor_skip</key><value>sensor_skip</value></param>
</block>
<block>
<key>fbmc1_fbmc_tagged_stream_to_pdu</key>
<param><key>id</key><value>fbmc1_fbmc_tagged_stream_to_pdu_0</value></param>
<param><key>veclength</key><value>vec</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>vec</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_1</value></param>
<param><key>fft_size</key><value>vec</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>737.5e6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_1</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>20</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>fbmc1_fbmc_payload_generator_0</sink_block_id><source_key>pdus</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_1</source_block_id><sink_block_id>fbmc1_fbmc_payload_generator_0</sink_block_id><source_key>pdus</source_key><sink_key>control in</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>fbmc1_fbmc_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_add_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_carrier_allocator_0</source_block_id><sink_block_id>fbmc1_fbmc_oqam_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_log_chann_state_0</source_block_id><sink_block_id>fbmc1_fbmc_payload_generator_0</sink_block_id><source_key>channel control</source_key><sink_key>ch state in</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_mac_encoder_0</source_block_id><sink_block_id>fbmc1_fbmc_phy_encoder_0</sink_block_id><source_key>mac out</source_key><sink_key>phy in</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_oqam_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_p2s_0</source_block_id><sink_block_id>fbmc1_fbmc_add_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_p2s_1</source_block_id><sink_block_id>fbmc1_fbmc_add_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_payload_generator_0</source_block_id><sink_block_id>fbmc1_fbmc_mac_encoder_0</sink_block_id><source_key>app out</source_key><sink_key>mac in</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_payload_generator_0</source_block_id><sink_block_id>blocks_socket_pdu_1</sink_block_id><source_key>control out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_phy_encoder_0</source_block_id><sink_block_id>fbmc1_fbmc_carrier_allocator_0</sink_block_id><source_key>phy out</source_key><sink_key>caa in</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_ppn_0</source_block_id><sink_block_id>fbmc1_fbmc_p2s_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_ppn_0</source_block_id><sink_block_id>fbmc1_fbmc_p2s_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_sample_collector_0</source_block_id><sink_block_id>fbmc1_fbmc_payload_generator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_sample_collector_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_tagged_stream_to_pdu_0</source_block_id><sink_block_id>fbmc1_fbmc_sample_collector_0</sink_block_id><source_key>frame out</source_key><sink_key>scl in</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>fbmc1_fbmc_ppn_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_1</source_block_id><sink_block_id>fbmc1_fbmc_log_chann_state_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_1</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
