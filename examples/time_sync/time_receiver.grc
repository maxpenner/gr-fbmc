<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>time_receiver</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoding_family</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fl</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>logical_channels</value></param>
<param><key>value</key><value>[48,     6,7,8,9,10,   12,13,14,15,16,17,18,19,20,21,22,23,24,    26,27,28,29,30,31,           33,34,35,36,37,38,    40,41,42,43,44,45,46,47,48,49,50,51,52,    54,55,56,57,58]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mode</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>print_rate</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>5000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sensor_skip</value></param>
<param><key>value</key><value>samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>spf</value></param>
<param><key>value</key><value>15</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vec</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>all_128</value></param>
<param><key>note</key><value>[100, 14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63,                       65,66,67,68,69,70,71,72,73,74,75,76,77,78,79,80,81,82,83,84,85,86,87,88,89,90,91,92,93,94,95,96,97,98,99,100,101,102,103,104,105,106,107,108,109,110,111,112,113,114]</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>all_128_0</value></param>
<param><key>note</key><value>[96, 14,15,16,17,18,19,20,21,22,23,24,         26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,                        46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63,                       65,66,67,68,69,70,71,72,73,74,75,76,77,78,79,80,81,82,                    84,85,86,87,88,89,90,91,92,93,94,95,96,97,98,99,100,101,102,            104,105,106,107,108,109,110,111,112,113,114]</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>all_256</value></param>
<param><key>note</key><value>[216, 20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63,64,65,66,67,68,69,70,71,72,73,74,75,76,77,78,79,80,81,82,83,84,85,86,87,88,89,90,91,92,93,94,95,96,97,98,99,100,101,102,103,104,105,106,107,108,109,110,111,112,113,114,115,116,117,118,119,120,121,122,123,124,125,126,127,                   129,130,131,132,133,134,135,136,137,138,139,140,141,142,143,144,145,146,147,148,149,150,151,152,153,154,155,156,157,158,159,160,161,162,163,164,165,166,167,168,169,170,171,172,173,174,175,176,177,178,179,180,181,182,183,184,185,186,187,188,189,190,191,192,193,194,195,196,197,198,199,200,201,202,203,204,205,206,207,208,209,210,211,212,213,214,215,216,217,218,219,220,221,222,223,224,225,226,227,228,229,230,231,232,233,234,235,236]</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>all_256_0</value></param>
<param><key>note</key><value>[192, 30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,            52,53,54,55,56,57,58,59,60,61,62,63,64,65,66,67,68,69,70,71,72,73,74,75,76,77,78,79,80,81,82,83,84,85,86,87,88,89,90,91,92,93,94,95,96,97,98,99,100,            102,103,104,105,106,107,108,109,110,111,112,113,114,115,116,117,118,119,120,121,122,123,124,125,126,127,                   129,130,131,132,133,134,135,136,137,138,139,140,141,142,143,144,145,146,147,148,149,150,151,152,153,154,                  156,157,158,159,160,161,162,163,164,165,166,167,168,169,170,171,172,173,174,175,176,177,178,179,180,181,182,183,184,185,186,187,188,189,190,191,192,193,194,195,196,197,198,199,200,201,202,203,204,             206,207,208,209,210,211,212,213,214,215,216,217,218,219,220,221,222,223,224,225,226]</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>all_64</value></param>
<param><key>note</key><value>[52,     6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,           33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58]</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>all_64_0</value></param>
<param><key>note</key><value>[48,     6,7,8,9,10,   12,13,14,15,16,17,18,19,20,21,22,23,24,    26,27,28,29,30,31,           33,34,35,36,37,38,    40,41,42,43,44,45,46,47,48,49,50,51,52,    54,55,56,57,58]</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>(fl+1)*vec</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>vec</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>num_items</key><value>samp_rate/2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>host</key><value>192.168.11.1</value></param>
<param><key>mtu</key><value>100000</value></param>
<param><key>port</key><value>52002</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0_0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>1472</value></param>
<param><key>port</key><value>8889</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>vec</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>vec</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>vec</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>length</key><value>vec*2</value></param>
<param><key>long_form</key><value>False</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>fbmc1_fbmc_equalizer</key>
<param><key>id</key><value>fbmc1_fbmc_equalizer_0</value></param>
<param><key>filterlength</key><value>fl</value></param>
<param><key>logical_channels</key><value>logical_channels</value></param>
<param><key>preamble_set</key><value>preamble</value></param>
<param><key>symbols_per_frame</key><value>spf</value></param>
<param><key>veclength</key><value>vec</value></param>
</block>
<block>
<key>fbmc1_fbmc_mac_decoder</key>
<param><key>id</key><value>fbmc1_fbmc_mac_decoder_0</value></param>
<param><key>encoding_family</key><value>encoding_family</value></param>
</block>
<block>
<key>fbmc1_fbmc_norm_akf_td</key>
<param><key>id</key><value>fbmc1_fbmc_norm_akf_td_0</value></param>
<param><key>akf_offset</key><value>vec</value></param>
<param><key>flush</key><value>1000</value></param>
<param><key>flush_rbo</key><value>100</value></param>
<param><key>nwin</key><value>vec</value></param>
<param><key>security</key><value>0.00049*0.01</value></param>
</block>
<block>
<key>fbmc1_fbmc_oqam_recv</key>
<param><key>id</key><value>fbmc1_fbmc_oqam_recv_0</value></param>
<param><key>veclength</key><value>vec</value></param>
</block>
<block>
<key>fbmc1_fbmc_phy_decoder</key>
<param><key>id</key><value>fbmc1_fbmc_phy_decoder_0</value></param>
<param><key>encoding_family</key><value>encoding_family</value></param>
<param><key>logical_channels</key><value>logical_channels</value></param>
<param><key>symbols_per_frame</key><value>spf</value></param>
<param><key>veclength</key><value>vec</value></param>
</block>
<block>
<key>fbmc1_fbmc_ppn_recv</key>
<param><key>id</key><value>fbmc1_fbmc_ppn_recv_0</value></param>
<param><key>filterlength</key><value>fl</value></param>
<param><key>veclength</key><value>vec</value></param>
</block>
<block>
<key>fbmc1_fbmc_sensor</key>
<param><key>id</key><value>fbmc1_fbmc_sensor_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>logical_channels</key><value>logical_channels</value></param>
<param><key>symbols_per_frame</key><value>spf</value></param>
<param><key>veclength</key><value>vec</value></param>
</block>
<block>
<key>fbmc1_fbmc_valve_td</key>
<param><key>id</key><value>fbmc1_fbmc_valve_td_0</value></param>
<param><key>filterlength</key><value>fl</value></param>
<param><key>init_lock</key><value>mode</value></param>
<param><key>plateau</key><value>3</value></param>
<param><key>preamble_set</key><value>preamble</value></param>
<param><key>symbols_per_frame</key><value>spf</value></param>
<param><key>sync_len</key><value>(fl+1)*vec</value></param>
<param><key>sync_refresh</key><value>1</value></param>
<param><key>sync_symm</key><value>(fl+1)*vec</value></param>
<param><key>sync_type</key><value>1</value></param>
<param><key>threshold</key><value>0.7</value></param>
<param><key>veclength</key><value>vec</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_1</value></param>
<param><key>fft_size</key><value>vec</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>spf*vec</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>print_rate</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>(fl*2+spf-2)*vec</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>print_rate</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>4000*3</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>print_rate</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_1_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>4000*3</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>print_rate</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>737.5e6</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>fbmc1_fbmc_valve_td_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleave_0</source_block_id><sink_block_id>fbmc1_fbmc_ppn_recv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>fbmc1_fbmc_sensor_0</sink_block_id><source_key>pdus</source_key><sink_key>control in</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>fbmc1_fbmc_norm_akf_td_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_equalizer_0</source_block_id><sink_block_id>fbmc1_fbmc_oqam_recv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_mac_decoder_0</source_block_id><sink_block_id>blocks_socket_pdu_0_0_0</sink_block_id><source_key>mac out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_norm_akf_td_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_norm_akf_td_0</source_block_id><sink_block_id>fbmc1_fbmc_valve_td_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_oqam_recv_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_oqam_recv_0</source_block_id><sink_block_id>fbmc1_fbmc_phy_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_oqam_recv_0</source_block_id><sink_block_id>fbmc1_fbmc_sensor_0</sink_block_id><source_key>0</source_key><sink_key>valve in</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_phy_decoder_0</source_block_id><sink_block_id>fbmc1_fbmc_mac_decoder_0</sink_block_id><source_key>phy out</source_key><sink_key>mac in</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_ppn_recv_0</source_block_id><sink_block_id>fft_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_sensor_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>control out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_sensor_0</source_block_id><sink_block_id>fbmc1_fbmc_valve_td_0</sink_block_id><source_key>valve out</source_key><sink_key>valve in</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_valve_td_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_valve_td_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_valve_td_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_valve_td_0</source_block_id><sink_block_id>fbmc1_fbmc_sensor_0</sink_block_id><source_key>valve out</source_key><sink_key>valve in</sink_key></connection>
<connection><source_block_id>fft_vxx_1</source_block_id><sink_block_id>fbmc1_fbmc_equalizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
