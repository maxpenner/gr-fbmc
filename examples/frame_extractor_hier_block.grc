<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fext</value></param>
<param><key>author</key><value>Maxim Penner</value></param>
<param><key>category</key><value>[FBMC1]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>FBMC Frame Extractor</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>param_0/2</value></param>
</block>
<block>
<key>fbmc1_fbmc_pdu_to_tagged_stream</key>
<param><key>id</key><value>fbmc1_fbmc_pdu_to_tagged_stream_0</value></param>
<param><key>microseconds</key><value>1000</value></param>
<param><key>veclength</key><value>param_0</value></param>
</block>
<block>
<key>fbmc1_fbmc_valve_fd</key>
<param><key>id</key><value>fbmc1_fbmc_valve_fd_0</value></param>
<param><key>filterlength</key><value>param_1</value></param>
<param><key>logical_channels</key><value>param_3</value></param>
<param><key>symbols_per_frame</key><value>param_2</value></param>
<param><key>veclength</key><value>param_0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>frame</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>frame_delayed</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>metric_in</value></param>
<param><key>type</key><value>int</value></param>
<param><key>vlen</key><value>param_0</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>ant_input</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_0</value></param>
<param><key>label</key><value>Veclength</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_1</value></param>
<param><key>label</key><value>Filterlength</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_2</value></param>
<param><key>label</key><value>Symbols Per Frame</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_3</value></param>
<param><key>label</key><value>Logical Channels</value></param>
<param><key>value</key><value>[1]</value></param>
</block>
<connection><source_block_id>blocks_stream_to_vector_1</source_block_id><sink_block_id>fbmc1_fbmc_valve_fd_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_pdu_to_tagged_stream_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_pdu_to_tagged_stream_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc1_fbmc_valve_fd_0</source_block_id><sink_block_id>fbmc1_fbmc_pdu_to_tagged_stream_0</sink_block_id><source_key>frame out</source_key><sink_key>frame in</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>fbmc1_fbmc_valve_fd_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>blocks_stream_to_vector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
